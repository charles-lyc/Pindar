# Repository charles-lyc/Pindar

## KiCad design hardware/kicad/app/gyro/gyro.kicad_pcb

Board: 2 copper layers, 8.8 x 12.0 mm, 6 parts (3 on the bottom side), 5 nets.

Parts:
C1, C2, C3, C4: 0.1uF; C_0805_2012Metric
U1: ICM-42688-P
U2: BMI088; PQFN50P450X300X100-16N

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, U1.5 (VDDIO), U1.8 (VDD), U2.3 (VDD), U2.11 (VDDIO)
/spi_clk: U1.13 (AP_SCL/AP_SCLK), U2.8 (SCL/SCK)
/spi_miso: U1.1 (AP_SDO/AP_AD0), U2.10 (SDO2), U2.15 (SDO1)
/spi_mosi: U1.14 (AP_SDA/AP_SDIO/AP_SDI), U2.9 (SDA/SDI)
GND: C1.2, C2.2, C3.2, C4.2, U1.2 (RESV_2), U1.3 (RESV_3), U1.6 (GND), U1.7 (RESV_7), U1.10 (RESV_10), U1.11 (RESV_11), U2.2 (NC), U2.4 (GNDA), U2.6 (GNDIO), U2.7 (PS)

## KiCad design hardware/kicad/cpu/esp32 s3/esp32 s3.kicad_pcb

Board: 2 copper layers, 45.0 x 45.0 mm, 44 parts (3 on the bottom side), 71 nets.

Parts:
C1: 47uF; CP_EIA-3216-12_Kemet-S
C2, C3, C4: 0.1uF; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
D2: SS54; D_SMB
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J2: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: USB_B_Micro; USB_Micro-B_YouCee
R1, R31: 1k; R_0603_1608Metric
R2: 10k; R_0805_2012Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: R; R_0603_1608Metric
R29, R30: 22; R_0603_1608Metric
SW1, SW2: SW_Push; SW_SPST_Omron_B3F-315x_Angled
U1: ESP32-S3-WROOM-1-N16R2; ESP32-S3-WROOM-1
U2: ICM-42688-P

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, J1.27, J1.28, J2.27, J2.28, R31.2, U1.2 (3V3), U2.5 (VDDIO), U2.8 (VDD)
+5V: D2.1 (K), J1.29, J1.30, J2.29, J2.30
/+BATT: J1.33, J1.34, J1.35, J1.36, J2.33, J2.34, J2.35, J2.36
/ADC_1: J1.1, J2.2, R3.2
/ADC_2: J1.2, J2.1, R4.2
/ADC_3: J1.3, J2.4, R5.2
/ADC_4: J1.4, J2.3, R6.2
/GPIO_1: J1.15, J2.16, R17.2
/GPIO_2: J1.16, J2.15, R18.2
/GPIO_3: J1.17, J2.18, R19.2
/GPIO_4: J1.18, J2.17, R20.2
/GPIO_5: J1.19, J2.20, R21.2
/GPIO_6: J1.20, J2.19, R22.2
/GPIO_7: J1.21, J2.22, R23.2
/GPIO_8: J1.22, J2.21, R24.2
/GPIO_9: J1.23, J2.24, R25.2
/GPIO_10: J1.24, J2.23, R26.2
/GPIO_11: J1.25, J2.26, R27.2
/GPIO_12: J1.26, J2.25, R28.2
/I2C_CLK: J1.10, J2.9, R12.2
/I2C_SDA: J1.9, J2.10, R11.2
/IMU_FSYNC: U1.23 (IO21), U2.9 (INT2/FSYNC/CLKIN)
/LED: D1.2 (A), U1.24 (IO47)
/SPI_CLK: J1.12, J2.11, R14.2
/SPI_CS: J1.11, J2.12, R13.2
/SPI_MISO: J1.14, J2.13, R16.2
/SPI_MOSI: J1.13, J2.14, R15.2
/UART1_Rx: J1.5, J2.6, R7.2
/UART1_Tx: J1.6, J2.5, R8.2
/UART2_Rx: J1.7, J2.8, R9.2
/UART2_Tx: J1.8, J2.7, R10.2
/adc1_ch3: R3.1, U1.4 (IO4)
/adc1_ch4: R4.1, U1.5 (IO5)
/adc1_ch5: R5.1, U1.6 (IO6)
/adc1_ch6: R6.1, U1.7 (IO7)
/gpio1: R17.1, U1.25 (IO48)
/gpio2: R18.1, U1.26 (IO45)
/gpio3: R19.1, U1.28 (IO35)
/gpio4: R20.1, U1.29 (IO36)
/gpio5: R21.1, U1.30 (IO37)
/gpio6: R22.1, U1.31 (IO38)
/gpio7: R23.1, U1.32 (IO39)
/gpio8: R24.1, U1.33 (IO40)
/gpio9: R25.1, U1.34 (IO41)
/gpio10: R26.1, U1.35 (IO42)
/gpio11: R27.1, U1.38 (IO2)
/gpio12: R28.1, U1.39 (IO1)
/i2c_clk: R12.1, U1.11 (IO18)
/i2c_sda: R11.1, U1.10 (IO17)
/spi2_clk: U1.21 (IO13), U2.13 (AP_SCL/AP_SCLK)
/spi2_cs: U1.22 (IO14), U2.12 (AP_CS)
/spi2_miso: U1.19 (IO11), U2.1 (AP_SDO/AP_AD0)
/spi2_mosi: U1.20 (IO12), U2.14 (AP_SDA/AP_SDIO/AP_SDI)
/spi3_clk: R14.1, U1.16 (IO46)
/spi3_cs: R13.1, U1.15 (IO3)
/spi3_miso: R16.1, U1.18 (IO10)
/spi3_mosi: R15.1, U1.17 (IO9)
/uart0_rx: R7.1, U1.36 (RXD0)
/uart0_tx: R8.1, U1.37 (TXD0)
/uart1_rx: R9.1, U1.8 (IO15)
/uart1_tx: R10.1, U1.9 (IO16)
/usb+: R29.2, U1.14 (IO20)
/usb-: R30.2, U1.13 (IO19)
GND: C1.2, C2.2, C3.2, C4.2, J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J2.31, J2.32, J2.37, J2.38, J2.39, J2.40, J3.5 (GND), J3.6 (Shield), R2.1, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U1.41_10 (GND), U1.41_11 (GND), U1.41_12 (GND), U1.41_13 (GND), U1.41_14 (GND), U1.41_15 (GND), U1.41_16 (GND), U1.41_17 (GND), U1.41_18 (GND), U1.41_19 (GND), U1.41_20 (GND), U1.41_21 (GND), U2.2 (RESV_2), U2.3 (RESV_3), U2.6 (GND), U2.7 (RESV_7), U2.10 (RESV_10), U2.11 (RESV_11)
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), J3.1 (VBUS)
unnamed: J3.3 (D+), R29.1
unnamed: J3.2 (D-), R30.1
unnamed: R1.1, SW1.2
unnamed: R31.1, SW2.2, U1.3 (EN)
unnamed: R1.2, U1.27 (IO0)

File hardware/kicad/cpu/esp32 s3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_EIA-3216-12_Kemet-S,1,47uF,
"C2, C3, C4",0805,3,0.1uF,
D1,0805,1,LED,
D2,D_SMB,1,SS54,
J1,PinHeader_2x20_P1.27mm_Vertical_SMD,1,TOP,
J2,PinHeader_2x20_P1.27mm_Vertical_SMD,1,BUTTOM,
J3,USB_Micro-B_YouCee,1,USB_B_Micro,
"R1, R31",0603,2,1k,
"R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R3, R4, R5, R6, R7, R8, R9",0603,26,R,
R2,0805,1,10k,
"R29, R30",0603,2,22,
"SW1, SW2",SW_SPST_Omron_B3F-315x_Angled,2,SW_Push,
U1,ESP32-S3-WROOM-1,1,ESP32-S3-WROOM-1-N16R2,
U2,ICM-42688-P,1,ICM-42688-P,

## KiCad design hw/kicad/app/motor/dc/dc.kicad_pcb

Board: 2 copper layers, 45.0 x 45.0 mm, 23 parts (1 on the bottom side), 39 nets.

Parts:
C1, C3, C5: 10uF; CP_Elec_6.3x5.4
C2, C4, C6, C9, C10, C11: 0.1uF; C_0805_2012Metric
J: Motor 1; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: Motor 2; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J4: Motor 3; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J6: BOTTUM; PinHeader_2x20_P1.27mm_Vertical_SMD
R1, R2, R3, R4, R5, R6: R; R_0805_2012Metric
U1, U2, U3: DRV8870DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
+3.3V: C9.1, C10.1, C11.1, J.6, J1.27, J1.28, J3.6, J4.6, J6.27, J6.28, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.4 (VREF), U2.4 (VREF), U3.4 (VREF)
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, J1.33, J1.34, J1.35, J1.36, J6.33, J6.34, J6.35, J6.36, U1.5 (VM), U2.5 (VM), U3.5 (VM)
/+5V: J1.29, J1.30, J6.29, J6.30
/ADC_1: J1.1, J6.2
/ADC_2: J1.2, J6.1
/ADC_3: J1.3, J6.4
/ADC_4: J1.4, J6.3
/CAN_H: J1.23, J4.4, J6.24, R6.1
/CAN_L: J1.24, J6.23
/ENC_1A: J.5, R2.1
/ENC_1B: J.4, J1.21, J6.22, R1.1
/ENC_2A: J3.5, R3.1
/ENC_2B: J1.22, J3.4, J6.21, R4.1
/ENC_3A: J4.5, R5.1
/GPIO_1: J1.15, J6.16, U1.3 (IN1)
/GPIO_2: J1.16, J6.15, U1.2 (IN2)
/GPIO_3: J1.17, J6.18, U2.3 (IN1)
/GPIO_4: J1.18, J6.17, U2.2 (IN2)
/GPIO_5: J1.19, J6.20, U3.3 (IN1)
/GPIO_6: J1.20, J6.19, U3.2 (IN2)
/I2C_CLK: J1.10, J6.9
/I2C_SDA: J1.9, J6.10
/OUT1: J.1, U1.6 (OUT1)
/OUT2: J.2, U1.8 (OUT2)
/OUT3: J3.1, U2.6 (OUT1)
/OUT4: J3.2, U2.8 (OUT2)
/OUT5: J4.1, U3.6 (OUT1)
/OUT6: J4.2, U3.8 (OUT2)
/SPI_CLK: J1.12, J6.11
/SPI_CS: J1.11, J6.12
/SPI_MISO: J1.14, J6.13
/SPI_MOSI: J1.13, J6.14
/UART1_RX: J1.5, J6.6
/UART1_TX: J1.6, J6.5
/UART2_RX: J1.7, J6.8
/UART2_TX: J1.8, J6.7
/USB+: J1.25, J6.26
/USB-: J1.26, J6.25
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, J.3, J.MP (MountPin), J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J3.3, J3.MP (MountPin), J4.3, J4.MP (MountPin), J6.31, J6.32, J6.37, J6.38, J6.39, J6.40, U1.1 (GND), U1.7 (ISEN), U1.9 (GND), U2.1 (GND), U2.7 (ISEN), U2.9 (GND), U3.1 (GND), U3.7 (ISEN), U3.9 (GND)

## KiCad design hw/kicad/base/12V/12V.kicad_pcb

Parts:
C1: 10uF; C_0805_2012Metric
C2, C4, C5, C9: 0.1uF; C_0805_2012Metric
C3, C8: 220uF; CP_Elec_6.3x7.7
C6: 220uF; CP_EIA-6032-28_Kemet-C
C10: 47uF; CP_EIA-3216-12_Kemet-S
D1, D7, D8: SS54; D_SMB
D2, D3, D4, D5, D6: 1N5819; D_SOD-323
D9: LED; LED_0805_2012Metric
J1: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
J2: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: XT30PW-M; XT30-PAD; PARTREV V1.2
J4: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
JUMP1: 0; R_0603_1608Metric
L1: 47uH; L_10.4x10.4_H4.8
R1, R5: 10k; R_0805_2012Metric
R2: 2k; R_0805_2012Metric
R3, R4: 22; R_0805_2012Metric
U1: LM1117MP-3.3; SOT-223-3_TabPin2
U2: LM2596S-5; TO-263-5_TabPin3
U3: CP2102N-Axx-xQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm

Connections:
+3.3V: C2.1, C10.1, D9.2 (A), J2.27, J2.28, J4.27, J4.28, U1.2 (VO)
+5V: C9.1, D7.1 (K), D8.1 (K), J2.29, J2.30, J4.29, J4.30, U1.3 (VI)
+BATT: C3.1, C8.1, J2.33, J2.34, J2.35, J2.36, J3.2 (-), J4.33, J4.34, J4.35, J4.36, R1.1, U2.1 (VIN)
/ADC_1: J2.1, J4.2, R1.2, R2.1
/ADC_2: J2.2, J4.1
/ADC_3: J2.3, J4.4
/ADC_4: J2.4, J4.3
/CAN_H: J2.15, J4.16
/CAN_L: J2.16, J4.15
/GPIO_1: J2.19, J4.20
/GPIO_2: J2.20, J4.19
/GPIO_3: J2.21, J4.22
/GPIO_4: J2.22, J4.21
/GPIO_5: J2.23, J4.24
/GPIO_6: J2.24, J4.23
/GPIO_7: J2.25, J4.26
/GPIO_8: J2.26, J4.25
/I2C_CLK: J2.10, J4.9
/I2C_SDA: J2.9, J4.10
/SPI_CLK: J2.12, J4.11
/SPI_CS: J2.11, J4.12
/SPI_MISO: J2.14, J4.13
/SPI_MOSI: J2.13, J4.14
/UART1_RX: D6.1 (K), J2.5, J4.6, U3.26 (TXD)
/UART1_TX: D5.1 (K), J2.6, J4.5, U3.25 (RXD)
/UART2_RX: J2.7, J4.8
/UART2_TX: J2.8, J4.7
/USB+: D2.1 (K), J2.17, J4.18, R3.2, U3.4 (D+)
/USB-: D3.1 (K), J2.18, J4.17, R4.2, U3.5 (D-)
GND: C1.1, C2.2, C3.2, C4.1, C5.2, C6.2, C8.2, C9.2, C10.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), J1.5 (GND), J1.6 (Shield), J2.31, J2.32, J2.37, J2.38, J2.39, J2.40, J3.1 (+), J4.31, J4.32, J4.37, J4.38, J4.39, J4.40, R2.2, R5.1, U1.1 (GND), U2.3 (GND), U2.5 (~ON/OFF), U3.3 (GND), U3.29 (GND)
unnamed: D1.1 (K), L1.1, U2.2 (OUT)
unnamed: C5.1, C6.1, D8.2 (A), L1.2, U2.4 (FB)
unnamed: D9.1 (K), R5.2
unnamed: J1.3 (D+), R3.1
unnamed: J1.2 (D-), R4.1
unnamed: C4.2, JUMP1.2, U3.7 (VREGIN), U3.8 (VBUS)
VBUS: C1.2, D4.1 (K), D7.2 (A), J1.1 (VBUS), JUMP1.1

Notes on the sheet:
这里只是简单的隔离开，如果不希望电压掉太多，用PMEG2010AEH这类，基本能在4.7V。 这里因为懒，就一律用SS54

Board: 2 copper layers, 45.0 x 45.0 mm, 32 parts (2 on the bottom side), 37 nets.

File hw/kicad/base/12V/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C9",CP_EIA-3528-21_Kemet-B,3,10uF,
"C2, C4, C5",0603,3,0.1uF,
"C3, C8",CP_Elec_6.3x7.7,2,220uF,
C6,CP_EIA-3528-21_Kemet-B,1,220uF,
"D1, D7, D8",D_SMB,3,SS54,
"D2, D3, D4, D5, D6",D_SOD-323,5,1N5819,
J1,USB_Micro-B_Molex_47346-0001,1,USB_B_Micro,
J2,PinHeader_2x20_P1.27mm_Vertical_SMD,1,TOP,
J3,XT60-PW-M,1,XT60PW-M,
J4,PinHeader_2x20_P1.27mm_Vertical_SMD,1,BUTTOM,
L1,L_10.4x10.4_H4.8,1,47uH,
R1,0201,1,10k,
R2,0201,1,2k,
"R3, R4",0201,2,22,
U1,SOT-223-3_TabPin2,1,LM1117MP-3.3,
U2,TO-263-5_TabPin3,1,LM2596S-5,
U3,QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm,1,CP2102N-Axx-xQFN28,
