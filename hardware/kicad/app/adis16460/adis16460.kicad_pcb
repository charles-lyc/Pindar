# Repository charles-lyc/Pindar

File README.md:

# Pindar
电子积木

# What is Pindar?
Pindar是什么？它的取名来自中文“拼搭”，初衷是遵循易用性、便携性、可扩展性的原则而设计的一套开发套件（硬件）。

Pindar为了快速建立项目的硬件而生，是对平时常见小项目的一次浅浅的解构和模块化。

# Some details
它包含三种type类型的板子：
- type base：类似电脑主板，负责电源输出和管理
- type cpu：负责计算
- type drv：专为项目提供的硬件（允许多个，只要保证io不冲突）

它提供了几种常见的功能接口：
- adc
- uart
- i2c
- spi
- gpio
- power: 3.3V 5.0V Vbatt

我使用的开发工具是KiCad 7.

# How to use it?
S-N-A-P!

仅仅是简单的把你需要的模块叠在一起（玩法类似Arduino），伴随一阵清脆的Click声（等将来找到合适的连接器能发出此声音之后 = =）就可以啦！

# Run your code
估计没人会对这个项目感兴趣，但万一0.1%的可能性你认可它，加上你有自己的想法和一点点动手能力，就可以将它实现成Pindar的type app板，无论你用什么硬件EDA设计，只要**基于template的板框和板间的连接器**设计就行。剩下的电源、总线、io，Pindar都会为你提供支持。

在安装好某个type drv板后，你可以为它写几个驱动（通常放在drivers里面），并让你的应用以task或者thread的形式运行在rtos上面（可以继承Pindar类，也可以重新写）。

期待新的作品。😋

# What about next?
我自己也会不定期更新自己平时玩的一些app板（四轴、平衡车、LVGL、全向轮、磁悬浮等等），后续考虑将Pindar的形态演变成slot插槽的形式。

## KiCad design hardware/kicad/app/adis16460/adis16460.kicad_pcb

Parts:
C1: Capacitor_Tantalum_SMD; CP_EIA-3216-12_Kemet-S
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J2: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: ADIS16460*; ADIS16460; MPN CLM-107-02
P1: BM08B-GHS-TBT(LF)(SN)(N); JST-GHS-1.25-BM08B
R1, R2: 0; R_0805_2012Metric

Connections:
+3.3V: C1.1, J1.27, J1.28, J2.27, J2.28, J3.11 (VDD), P1.1
/+5V: J1.29, J1.30, J2.29, J2.30
/+BATT: J1.33, J1.34, J1.35, J1.36, J2.33, J2.34, J2.35, J2.36
/ADC_1: J1.1, J2.2
/ADC_2: J1.2, J2.1
/ADC_3: J1.3, J2.4
/ADC_4: J1.4, J2.3
/DR: J3.1 (DR), P1.6, R1.1
/GPIO_1: J1.15, J2.16, R1.2
/GPIO_2: J1.16, J2.15, R2.2
/GPIO_3: J1.17, J2.18
/GPIO_4: J1.18, J2.17
/GPIO_5: J1.19, J2.20
/GPIO_6: J1.20, J2.19
/GPIO_7: J1.21, J2.22
/GPIO_8: J1.22, J2.21
/GPIO_9: J1.23, J2.24
/GPIO_10: J1.24, J2.23
/GPIO_11: J1.25, J2.26
/GPIO_12: J1.26, J2.25
/I2C_CLK: J1.10, J2.9
/I2C_SDA: J1.9, J2.10
/RST: J3.8 (RST), P1.7, R2.1
/SPI_CLK: J1.12, J2.11, J3.3 (SCLK), P1.3
/SPI_CS: J1.11, J2.12, J3.6 (CS), P1.2
/SPI_MISO: J1.14, J2.13, J3.4 (DOUT), P1.4
/SPI_MOSI: J1.13, J2.14, J3.5 (DIN), P1.5
/UART1_Rx: J1.5, J2.6
/UART1_Tx: J1.6, J2.5
/UART2_Rx: J1.7, J2.8
/UART2_Tx: J1.8, J2.7
GND: C1.2, J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J2.31, J2.32, J2.37, J2.38, J2.39, J2.40, J3.13 (GND), P1.8, P1.P1 (SHIELD), P1.P2 (SHIELD)

Board: 2 copper layers, 45.0 x 45.0 mm, 7 parts (1 on the bottom side), 32 nets.

File hardware/kicad/app/adis16460/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_EIA-3216-12_Kemet-S,1,Capacitor_Tantalum_SMD,
J1,PinHeader_2x20_P1.27mm_Vertical_SMD,1,TOP,
J2,PinHeader_2x20_P1.27mm_Vertical_SMD,1,BUTTOM,
J3,ADIS16460,1,ADIS16460*,CLM-107-02
P1,JST-GHS-1.25-BM08B,1,BM08B-GHS-TBT(LF)(SN)(N),
"R1, R2",0805,2,0,

## KiCad design hw/kicad/base/power_16V/power_16V.kicad_pcb

Parts:
C1, C10: 220uF; CP_Elec_6.3x7.7
C2, C6, C8, C9, C11, C12: 0.1uF; C_0805_2012Metric
C3: 47uF; CP_EIA-3216-12_Kemet-S
C4: 4.7uF; C_0805_2012Metric
C5: 1uF; C_0805_2012Metric
C7: 220uF; CP_EIA-6032-28_Kemet-C
D1, D3, D6: SS54; D_SMB
D2, D4, D5: 1N5819; D_SOD-323
D7, D8, D9: LED; LED_0805_2012Metric
J1: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
J2: XT30PW-M; XT30-PAD; PARTREV V1.2
J3: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J4: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
L1: 47uH; L_10.4x10.4_H4.8
R1, R2: 22; R_0603_1608Metric
R3, R4, R5: 1k; R_0805_2012Metric
R6: 10k; R_0805_2012Metric
R7: 2k; R_0805_2012Metric
U1: LM2596S-5; TO-263-5_TabPin3
U2: LM1117MP-3.3; SOT-223-3_TabPin2
U3: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U4: ACS712xLCTR-05B; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C3.1, C6.1, D7.2 (A), J3.27, J3.28, J4.27, J4.28, U2.2 (VO)
+5V: C2.1, D1.1 (K), D6.1 (K), J3.29, J3.30, J4.29, J4.30, U2.3 (VI)
+BATT: C1.1, C10.1, J3.33, J3.34, J3.35, J3.36, J4.33, J4.34, J4.35, J4.36, R6.1, U1.1 (VIN), U4.3 (IP-), U4.4 (IP-)
/+BATT_IN: J2.1 (+), U4.1 (IP+), U4.2 (IP+)
/ADC_1: J3.1, J4.2, R6.2, R7.1
/ADC_2: C12.1, J3.2, J4.1, U4.7 (VIOUT)
/ADC_3: J3.3, J4.4
/ADC_4: J3.4, J4.3
/DCDC_+5V: C7.1, C8.1, D6.2 (A), L1.2, U1.4 (FB), U4.8 (VCC)
/GPIO_1: J3.17, J4.18
/GPIO_2: J3.18, J4.17
/GPIO_3: J3.19, J4.20
/GPIO_4: J3.20, J4.19
/GPIO_5: J3.21, J4.22
/GPIO_6: J3.22, J4.21
/GPIO_7: J3.23, J4.24
/GPIO_8: J3.24, J4.23
/GPIO_9: J3.25, J4.26
/GPIO_10: J3.26, J4.25
/I2C_CLK: J3.12, J4.11
/I2C_SDA: J3.11, J4.12
/SPI_CLK: J3.14, J4.13
/SPI_CS: J3.13, J4.14
/SPI_MISO: J3.16, J4.15
/SPI_MOSI: J3.15, J4.16
/UART1_Rx: J3.5, J4.6, U3.21 (TXD)
/UART1_Tx: J3.6, J4.5, U3.20 (RXD)
/UART2_Rx: J3.7, J4.8
/UART2_Tx: J3.8, J4.7
/UART3_Rx: J3.9, J4.10
/UART3_Tx: J3.10, J4.9
/VIO: C9.2, R4.2, R5.2, U3.5 (VIO), U3.6 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), J1.5 (GND), J1.6 (Shield), J2.2 (-), J3.31, J3.32, J3.37, J3.38, J3.39, J3.40, J4.31, J4.32, J4.37, J4.38, J4.39, J4.40, R3.1, R7.2, U1.3 (GND), U1.5 (~ON/OFF), U2.1 (GND), U3.2 (GND), U3.25 (GND), U4.5 (GND)
unnamed: C5.2, D1.2 (A), D2.1 (K), J1.1 (VBUS), U3.7 (REGIN), U3.8 (VBUS)
unnamed: D3.1 (K), L1.1, U1.2 (OUT)
unnamed: D4.1 (K), R2.2, U3.4 (D-)
unnamed: D5.1 (K), R1.2, U3.3 (D+)
unnamed: D7.1 (K), R3.2
unnamed: D8.2 (A), R4.1
unnamed: D8.1 (K), U3.13 (RXT/GPIO.1)
unnamed: D9.2 (A), R5.1
unnamed: D9.1 (K), U3.14 (TXT/GPIO.0)
unnamed: J1.3 (D+), R1.1
unnamed: J1.2 (D-), R2.1
unnamed: C4.1, U3.16 (VPP)
unnamed: C11.1, U4.6 (FILTER)

Notes on the sheet:
这里只是简单的隔离开，如果不希望电压掉太多，用PMEG2010AEH这类，基本能在4.7V。 这里因为懒，就一律用SS54

Board: 2 copper layers, 45.0 x 45.0 mm, 36 parts (1 on the bottom side), 46 nets.

File hw/kicad/base/power_16V/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_2, ",,2,,
"C1, C10",CP_Elec_6.3x7.7,2,220uF,
"C11, C12, C2, C6, C8, C9",0805,6,0.1uF,
C3,CP_EIA-3216-12_Kemet-S,1,47uF,
C4,0805,1,4.7uF,
C5,0805,1,1uF,
C7,CP_EIA-6032-28_Kemet-C,1,220uF,
"D1, D3, D6",D_SMB,3,SS54,
"D2, D4, D5",D_SOD-323,3,1N5819,
"D7, D8, D9",0805,3,LED,
J1,USB_Micro-B_YouCee,1,USB_B_Micro,
J3,PinHeader_2x20_P1.27mm_Vertical_SMD,1,TOP,
J4,PinHeader_2x20_P1.27mm_Vertical_SMD,1,BUTTOM,
L1,L_10.4x10.4_H4.8,1,47uH,
"R1, R2",0603,2,22,
"R3, R4, R5",0805,3,1k,
R6,0805,1,10k,
R7,0805,1,2k,
U1,TO-263-5_TabPin3,1,LM2596S-5,
U2,SOT-223-3_TabPin2,1,LM1117MP-3.3,
U3,QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm,1,CP2104,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,ACS712xLCTR-05B,

## KiCad design hw/kicad/cpu/esp32 s3/esp32 s3.kicad_pcb

Parts:
C1: 47uF; CP_EIA-3216-12_Kemet-S
C2, C3, C4: 0.1uF; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
D2: SS54; D_SMB
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J2: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
R1, R31: 1k; R_0603_1608Metric
R2: 10k; R_0805_2012Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: R; R_0603_1608Metric
R29, R30: 22; R_0603_1608Metric
SW1, SW2: SW_Push; SW_SPST_Omron_B3F-315x_Angled
U1: ESP32-S3-WROOM-1-N16R2; ESP32-S3-WROOM-1; PARTREV v1.0
U2: ICM-42688-P; PARTREV 1.2

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, J1.27, J1.28, J2.27, J2.28, R31.2, U1.2 (3V3), U2.5 (VDDIO), U2.8 (VDD)
+5V: D2.1 (K), J1.29, J1.30, J2.29, J2.30
/+BATT: J1.33, J1.34, J1.35, J1.36, J2.33, J2.34, J2.35, J2.36
/ADC_1: J1.1, J2.2, R3.2
/ADC_2: J1.2, J2.1, R4.2
/ADC_3: J1.3, J2.4, R5.2
/ADC_4: J1.4, J2.3, R6.2
/GPIO_1: J1.15, J2.16, R17.2
/GPIO_2: J1.16, J2.15, R18.2
/GPIO_3: J1.17, J2.18, R19.2
/GPIO_4: J1.18, J2.17, R20.2
/GPIO_5: J1.19, J2.20, R21.2
/GPIO_6: J1.20, J2.19, R22.2
/GPIO_7: J1.21, J2.22, R23.2
/GPIO_8: J1.22, J2.21, R24.2
/GPIO_9: J1.23, J2.24, R25.2
/GPIO_10: J1.24, J2.23, R26.2
/GPIO_11: J1.25, J2.26, R27.2
/GPIO_12: J1.26, J2.25, R28.2
/I2C_CLK: J1.10, J2.9, R12.2
/I2C_SDA: J1.9, J2.10, R11.2
/IMU_FSYNC: U1.23 (IO21), U2.9 (INT2/FSYNC/CLKIN)
/LED: D1.2 (A), U1.24 (IO47)
/SPI_CLK: J1.12, J2.11, R14.2
/SPI_CS: J1.11, J2.12, R13.2
/SPI_MISO: J1.14, J2.13, R16.2
/SPI_MOSI: J1.13, J2.14, R15.2
/UART1_Rx: J1.5, J2.6, R7.2
/UART1_Tx: J1.6, J2.5, R8.2
/UART2_Rx: J1.7, J2.8, R9.2
/UART2_Tx: J1.8, J2.7, R10.2
/adc1_ch3: R3.1, U1.4 (IO4)
/adc1_ch4: R4.1, U1.5 (IO5)
/adc1_ch5: R5.1, U1.6 (IO6)
/adc1_ch6: R6.1, U1.7 (IO7)
/gpio1: R17.1, U1.25 (IO48)
/gpio2: R18.1, U1.26 (IO45)
/gpio3: R19.1, U1.28 (IO35)
/gpio4: R20.1, U1.29 (IO36)
/gpio5: R21.1, U1.30 (IO37)
/gpio6: R22.1, U1.31 (IO38)
/gpio7: R23.1, U1.32 (IO39)
/gpio8: R24.1, U1.33 (IO40)
/gpio9: R25.1, U1.34 (IO41)
/gpio10: R26.1, U1.35 (IO42)
/gpio11: R27.1, U1.38 (IO2)
/gpio12: R28.1, U1.39 (IO1)
/i2c_clk: R12.1, U1.11 (IO18)
/i2c_sda: R11.1, U1.10 (IO17)
/spi2_clk: U1.21 (IO13), U2.13 (AP_SCL/AP_SCLK)
/spi2_cs: U1.22 (IO14), U2.12 (AP_CS)
/spi2_miso: U1.19 (IO11), U2.1 (AP_SDO/AP_AD0)
/spi2_mosi: U1.20 (IO12), U2.14 (AP_SDA/AP_SDIO/AP_SDI)
/spi3_clk: R14.1, U1.16 (IO46)
/spi3_cs: R13.1, U1.15 (IO3)
/spi3_miso: R16.1, U1.18 (IO10)
/spi3_mosi: R15.1, U1.17 (IO9)
/uart0_rx: R7.1, U1.36 (RXD0)
/uart0_tx: R8.1, U1.37 (TXD0)
/uart1_rx: R9.1, U1.8 (IO15)
/uart1_tx: R10.1, U1.9 (IO16)
/usb+: R29.2, U1.14 (IO20)
/usb-: R30.2, U1.13 (IO19)
GND: C1.2, C2.2, C3.2, C4.2, J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J2.31, J2.32, J2.37, J2.38, J2.39, J2.40, J3.5 (GND), J3.6 (Shield), R2.1, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U1.41_10 (GND), U1.41_11 (GND), U1.41_12 (GND), U1.41_13 (GND), U1.41_14 (GND), U1.41_15 (GND), U1.41_16 (GND), U1.41_17 (GND), U1.41_18 (GND), U1.41_19 (GND), U1.41_20 (GND), U1.41_21 (GND), U2.2 (RESV_2), U2.3 (RESV_3), U2.6 (GND), U2.7 (RESV_7), U2.10 (RESV_10), U2.11 (RESV_11)
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), J3.1 (VBUS)
unnamed: J3.3 (D+), R29.1
unnamed: J3.2 (D-), R30.1
unnamed: R1.1, SW1.2
unnamed: R31.1, SW2.2, U1.3 (EN)
unnamed: R1.2, U1.27 (IO0)

Notes on the sheet:
烧录固件时，长按sw1调用esp_restart重启至boot模式，刚好io0此时也拉低

Board: 2 copper layers, 45.0 x 45.0 mm, 44 parts (3 on the bottom side), 71 nets.

File hw/kicad/cpu/esp32 s3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_EIA-3216-12_Kemet-S,1,47uF,
"C2, C3, C4",0805,3,0.1uF,
D1,0805,1,LED,
D2,D_SMB,1,SS54,
J1,PinHeader_2x20_P1.27mm_Vertical_SMD,1,TOP,
J2,PinHeader_2x20_P1.27mm_Vertical_SMD,1,BUTTOM,
J3,USB_Micro-B_Wuerth_629105150521,1,USB_B_Micro,
R1,0603,1,1k,
"R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R3, R4, R5, R6, R7, R8, R9",0603,26,R,
R2,0805,1,10k,
"R29, R30",0603,2,22,
SW1,SW_SPST_Omron_B3F-315x_Angled,1,SW_Push,
U1,ESP32-S3-WROOM-1,1,ESP32-S3-WROOM-1-N16R2,
U2,ICM-42688-P,1,ICM-42688-P,

## KiCad design hw/kicad/base/io/io.kicad_pcb

Board: 2 copper layers, 45.0 x 45.0 mm, 9 parts (1 on the bottom side), 30 nets.

Parts:
J1: SPI; JST_GH_BM06B-GHS-TBT_1x06-1MP_P1.25mm_Vertical
J2: SERVO; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J3: UART 1; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J4: I2C; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J5: RADIO; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J6: UART 2; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J7: ADC; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J8: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J9: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD

Connections:
+3.3V: J1.1, J2.2, J3.1, J4.1, J5.2, J6.1, J7.1, J8.27, J8.28, J9.27, J9.28
+5V: J2.1, J5.1, J8.29, J8.30, J9.29, J9.30
/+BATT: J8.33, J8.34, J8.35, J8.36, J9.33, J9.34, J9.35, J9.36
/ADC_1: J8.1, J9.2
/ADC_2: J8.2, J9.1
/ADC_3: J7.2, J8.3, J9.4
/ADC_4: J7.3, J8.4, J9.3
/GPIO_1: J8.15, J9.16
/GPIO_2: J8.16, J9.15
/GPIO_3: J8.17, J9.18
/GPIO_4: J8.18, J9.17
/GPIO_5: J8.19, J9.20
/GPIO_6: J8.20, J9.19
/GPIO_7: J8.21, J9.22
/GPIO_8: J8.22, J9.21
/GPIO_9: J8.23, J9.24
/GPIO_10: J8.24, J9.23
/GPIO_11: J2.3, J8.25, J9.26
/GPIO_12: J5.3, J8.26, J9.25
/I2C_CLK: J4.3, J8.10, J9.9
/I2C_SDA: J4.2, J8.9, J9.10
/SPI_CLK: J1.3, J8.12, J9.11
/SPI_CS: J1.2, J8.11, J9.12
/SPI_MISO: J1.5, J8.14, J9.13
/SPI_MOSI: J1.4, J8.13, J9.14
/UART1_Rx: J3.2, J8.5, J9.6
/UART1_Tx: J3.3, J8.6, J9.5
/UART2_Rx: J6.2, J8.7, J9.8
/UART2_Tx: J6.3, J8.8, J9.7
GND: J1.6, J1.MP (MountPin), J2.4, J2.MP (MountPin), J3.4, J3.MP (MountPin), J4.4, J4.MP (MountPin), J5.4, J5.MP (MountPin), J6.4, J6.MP (MountPin), J7.4, J7.MP (MountPin), J8.31, J8.32, J8.37, J8.38, J8.39, J8.40, J9.31, J9.32, J9.37, J9.38, J9.39, J9.40

## KiCad design hw/kicad/app/gyro/gyro.kicad_pcb

Board: 2 copper layers, 8.8 x 12.0 mm, 6 parts (3 on the bottom side), 5 nets.

Parts:
C1, C2, C3, C4: 0.1uF; C_0805_2012Metric
U1: ICM-42688-P
U2: BMI088; PQFN50P450X300X100-16N

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, U1.5 (VDDIO), U1.8 (VDD), U2.3 (VDD), U2.11 (VDDIO)
/spi_clk: U1.13 (AP_SCL/AP_SCLK), U2.8 (SCL/SCK)
/spi_miso: U1.1 (AP_SDO/AP_AD0), U2.10 (SDO2), U2.15 (SDO1)
/spi_mosi: U1.14 (AP_SDA/AP_SDIO/AP_SDI), U2.9 (SDA/SDI)
GND: C1.2, C2.2, C3.2, C4.2, U1.2 (RESV_2), U1.3 (RESV_3), U1.6 (GND), U1.7 (RESV_7), U1.10 (RESV_10), U1.11 (RESV_11), U2.2 (NC), U2.4 (GNDA), U2.6 (GNDIO), U2.7 (PS)

File hw/kicad/app/gyro/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_8, _7, _6, _5, _4, _3, _2, ",,8,,
"C1, C2, C3, C4",0805,4,0.1uF,
U1,ICM-42688-P,1,ICM-42688-P,
U2,PQFN50P450X300X100-16N,1,BMI088,

## KiCad design hw/kicad/app/motor/dc_motor/dc_motor.kicad_pcb

Board: 2 copper layers, 45.0 x 45.0 mm, 22 parts (1 on the bottom side), 38 nets.

Parts:
C1, C3, C5, C17: 10uF; CP_Elec_6.3x5.4
C2, C4, C6, C9, C10, C11, C16, C18: 0.1uF; C_0805_2012Metric
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J2: Motor 1; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J3: Motor 2; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J4: Motor 3; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J5: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
J6: Motor 4; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
U1, U2, U3, U6: DRV8870DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
+3.3V: C9.1, C10.1, C11.1, C16.1, J1.27, J1.28, J2.1, J3.1, J4.1, J5.27, J5.28, J6.1, U1.4 (VREF), U2.4 (VREF), U3.4 (VREF), U6.4 (VREF)
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C17.1, C18.1, J1.33, J1.34, J1.35, J1.36, J5.33, J5.34, J5.35, J5.36, U1.5 (VM), U2.5 (VM), U3.5 (VM), U6.5 (VM)
/+5V: J1.29, J1.30, J5.29, J5.30
/ADC_1: J1.1, J5.2
/ADC_2: J1.2, J5.1
/ADC_3: J1.3, J5.4
/ADC_4: J1.4, J5.3
/ENC_1A: J1.23, J2.2, J5.24
/ENC_2A: J1.24, J3.2, J5.23
/ENC_3A: J1.25, J4.2, J5.26
/ENC_4A: J1.26, J5.25, J6.2
/GPIO_1: J1.15, J5.16, U1.3 (IN1)
/GPIO_2: J1.16, J5.15, U1.2 (IN2)
/GPIO_3: J1.17, J5.18, U2.3 (IN1)
/GPIO_4: J1.18, J5.17, U2.2 (IN2)
/GPIO_5: J1.19, J5.20, U3.3 (IN1)
/GPIO_6: J1.20, J5.19, U3.2 (IN2)
/GPIO_7: J1.21, J5.22, U6.3 (IN1)
/GPIO_8: J1.22, J5.21, U6.2 (IN2)
/I2C_CLK: J1.10, J5.9
/I2C_SDA: J1.9, J5.10
/OUT1: J2.5, U1.6 (OUT1)
/OUT2: J2.6, U1.8 (OUT2)
/OUT3: J3.5, U2.6 (OUT1)
/OUT4: J3.6, U2.8 (OUT2)
/OUT5: J4.5, U3.6 (OUT1)
/OUT6: J4.6, U3.8 (OUT2)
/OUT7: J6.5, U6.6 (OUT1)
/OUT8: J6.6, U6.8 (OUT2)
/SPI_CLK: J1.12, J5.11
/SPI_CS: J1.11, J5.12
/SPI_MISO: J1.14, J5.13
/SPI_MOSI: J1.13, J5.14
/UART1_Rx: J1.5, J5.6
/UART1_Tx: J1.6, J5.5
/UART2_Rx: J1.7, J5.8
/UART2_Tx: J1.8, J5.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C16.2, C17.2, C18.2, J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J2.4, J2.MP (MountPin), J3.4, J3.MP (MountPin), J4.4, J4.MP (MountPin), J5.31, J5.32, J5.37, J5.38, J5.39, J5.40, J6.4, J6.MP (MountPin), U1.1 (GND), U1.7 (ISEN), U1.9 (GND), U2.1 (GND), U2.7 (ISEN), U2.9 (GND), U3.1 (GND), U3.7 (ISEN), U3.9 (GND), U6.1 (GND), U6.7 (ISEN), U6.9 (GND)

## KiCad design hw/kicad/cpu/esp32 s3/esp32s3_wroom_1.kicad_pcb

Parts:
C1: 47uF; CP_EIA-3216-12_Kemet-S
C2, C3, C4: 0.1uF; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
D2: SS54; D_SMB
J1: TOP; PinHeader_2x20_P1.27mm_Vertical_SMD
J2: BUTTOM; PinHeader_2x20_P1.27mm_Vertical_SMD
J3: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
R1: 1k; R_0805_2012Metric
R2: 10k; R_0805_2012Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R21, R22, R23, R24, R25, R26, R27, R28: 100; R_0603_1608Metric
R29, R30: 22; R_0805_2012Metric
SW1: SW_Push; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W6.73mm_P2.54mm_LowProfile_J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
U1: ESP32-S3-WROOM-1-N16R2; ESP32-S3-WROOM-1; PARTREV v1.0
U2: ICM-42688-P; PARTREV 1.2

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, J1.27, J1.28, J2.27, J2.28, U1.2 (3V3), U1.3 (EN), U2.5 (VDDIO), U2.8 (VDD)
+5V: D2.1 (K), J1.29, J1.30, J2.29, J2.30
/+BATT: J1.33, J1.34, J1.35, J1.36, J2.33, J2.34, J2.35, J2.36
/ADC_1: J1.1, J2.2, R3.2
/ADC_2: J1.2, J2.1, R4.2
/ADC_3: J1.3, J2.4, R5.2
/ADC_4: J1.4, J2.3, R6.2
/GPIO_1: J1.17, J2.18, R21.2
/GPIO_2: J1.18, J2.17, R22.2
/GPIO_3: J1.19, J2.20, R23.2
/GPIO_4: J1.20, J2.19, R24.2
/GPIO_5: J1.21, J2.22, R25.2
/GPIO_6: J1.22, J2.21, R26.2
/GPIO_7: J1.23, J2.24, R27.2
/GPIO_8: J1.24, J2.23, R28.2
/GPIO_9: J1.25, J2.26, R17.2
/GPIO_10: J1.26, J2.25, R18.2
/I2C_CLK: J1.12, J2.11, R12.2
/I2C_SDA: J1.11, J2.12, R11.2
/IMU_FSYNC: U1.25 (IO48), U2.9 (INT2/FSYNC/CLKIN)
/LED: D1.2 (A), U1.12 (IO8)
/SPI_CLK: J1.14, J2.13, R14.2
/SPI_CS: J1.13, J2.14, R13.2
/SPI_MISO: J1.16, J2.15, R16.2
/SPI_MOSI: J1.15, J2.16, R15.2
/UART1_RX: R7.2
/UART1_Rx: J1.5, J2.6
/UART1_TX: R8.2
/UART1_Tx: J1.6, J2.5
/UART2_RX: R9.2
/UART2_Rx: J1.7, J2.8
/UART2_TX: R10.2
/UART2_Tx: J1.8, J2.7
/UART3_Rx: J1.9, J2.10
/UART3_Tx: J1.10, J2.9
/USB+: R29.2
/USB-: R30.2
/adc1_ch3: R3.1, U1.4 (IO4)
/adc1_ch4: R4.1, U1.5 (IO5)
/adc1_ch5: R5.1, U1.6 (IO6)
/adc1_ch6: R6.1, U1.7 (IO7)
/gpio1: R21.1, U1.28 (IO35)
/gpio2: R22.1, U1.29 (IO36)
/gpio3: R23.1, U1.30 (IO37)
/gpio4: R24.1, U1.31 (IO38)
/gpio5: R25.1, R26.1, U1.32 (IO39), U1.33 (IO40)
/gpio7: R27.1, U1.34 (IO41)
/gpio8: R28.1, U1.35 (IO42)
/gpio9: R17.1, U1.38 (IO2)
/gpio10: R18.1, U1.39 (IO1)
/i2c_clk: R11.1, U1.10 (IO17)
/i2c_sda: R12.1, U1.11 (IO18)
/spi2_clk: U1.19 (IO11)
/spi2_cs: U1.17 (IO9)
/spi2_miso: U1.20 (IO12)
/spi2_mosi: U1.18 (IO10)
/spi3_clk: R14.1, U1.22 (IO14), U2.13 (AP_SCL/AP_SCLK)
/spi3_cs: R13.1, U1.21 (IO13), U2.12 (AP_CS)
/spi3_miso: R16.1, U1.24 (IO47), U2.1 (AP_SDO/AP_AD0)
/spi3_mosi: R15.1, U1.23 (IO21), U2.14 (AP_SDA/AP_SDIO/AP_SDI)
/uart0_rx: R7.1, U1.36 (RXD0)
/uart0_tx: R8.1, U1.37 (TXD0)
/uart1_rx: R9.1, U1.9 (IO16)
/uart1_tx: R10.1, U1.8 (IO15)
/usb_d+: U1.14 (IO20)
/usb_d-: U1.13 (IO19)
GND: C1.2, C2.2, C3.2, C4.2, J1.31, J1.32, J1.37, J1.38, J1.39, J1.40, J2.31, J2.32, J2.37, J2.38, J2.39, J2.40, J3.5 (GND), J3.6 (Shield), R1.1, R2.1, U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U2.2 (RESV_2), U2.3 (RESV_3), U2.6 (GND), U2.7 (RESV_7), U2.10 (RESV_10), U2.11 (RESV_11)
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), J3.1 (VBUS)
unnamed: J3.3 (D+), R29.1
unnamed: J3.2 (D-), R30.1
unnamed: R1.2, SW1.1
unnamed: SW1.2, U1.27 (IO0)
